options:
  parameters:
    author: Lime Microsystems
    generate_options: no_gui
    id: test_xtrx_rx_null
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: baseband
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: RX Baseband [MHz]
    type: real
    value: '100.0'
  states: {state: disabled}
- name: baseband
  id: variable
  parameters:
    value: '100'
  states: {}
- name: cut_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Cutoff frequency
    start: 1e3
    step: 1e3
    stop: samp_rate/2
    value: 500e3
  states: {state: disabled}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Gain [dB]
    min_len: '70'
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {state: disabled}
- name: gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: lna_path
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: LNA Path
    label0: H
    label1: L
    label2: W
    num_opts: '3'
    option0: '1'
    option1: '2'
    option2: '3'
    type: int
    value: '1'
  states: {state: disabled}
- name: lna_path
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15e6
  states: {}
- name: trans_width
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Transition width
    start: 10e3
    step: '500'
    stop: 500e3
    value: 100e3
  states: {state: disabled}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '5'
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 2e6
    ch_align: 'False'
    channel_mode: '0'
    digital_bandw_ch0: 1.8e6
    gain_dB_ch0: gain
    lna_path_ch0: lna_path
    oversample: '0'
    rf_freq: baseband*1e6
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_freq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: baseband*1e6
    fftsize: '1024'
    gui_hint: 3,0,15,2
    name: '"Low Pass filtered"'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '48'
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [limesdr_source_0, '0', blocks_null_sink_0, '0']
- [limesdr_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
