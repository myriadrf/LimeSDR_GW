options:
  parameters:
    author: gwe
    generate_options: qt_gui
    id: test_miniv2_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freqTX
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: 50e3
    stop: 500e6
    value: 433e6
  states: {}
- name: gainTX
  id: variable_qtgui_range
  parameters:
    start: int(0)
    step: int(1)
    stop: int(40)
    value: int(20)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2.5e6)
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/dataTx.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    comment: |-
      Both Tx receives same signal

      - with constant source only the carrier is visible
      - with signal source a 1MHz cosine is mixed to carrier
      - with file source an arbitrary complex signal is produces
      (Uses 'D' to disable and 'E' to enable a source)

      - freqTx slider is used to change center frequency
      - gainTX slider is used to increase/decrease attenuation/gain
    note: Dual Channels TX test
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    bandwidth: 4e6
    center_freq: freqTX
    dev_args: driver=limesuiteng
    gain: '20'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_sink_x_0, '0']
- [analog_const_source_x_0, '0', soapy_limesdr_sink_0, '0']
- [analog_sig_source_x_0, '0', qtgui_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
