options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: limesdr_fft_output_project
    output_language: python
    title: FFT Example
  states: {}

blocks:
- name: RF_Frequency
  id: variable
  parameters:
    value: 1.0e9
  states: {}
- name: RX_Gain
  id: variable_qtgui_range
  parameters:
    label: RX GAIN, dB
    rangeType: int
    start: '0'
    step: '1'
    stop: '73'
    value: '1'
  states: {}
- name: SigFreq
  id: variable_qtgui_range
  parameters:
    label: Signal Freq, MHz
    start: '-5'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: TX_Gain
  id: variable_qtgui_range
  parameters:
    label: TX GAIN, dB
    rangeType: int
    start: '0'
    step: '1'
    stop: '73'
    value: '1'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: SigFreq*1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: float
    vlen: int(fft_size/2)
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: float
    vlen: int(fft_size/2)
  states: {}
- name: limesuiteng_sdrdevice_sink_0
  id: limesuiteng_sdrdevice_sink
  parameters:
    antenna: auto
    calibrate_dciq: Disabled
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: ''
    gain_generic: TX_Gain
    gfir_bandwidth: '0'
    link_format: i16
    lpf: 20e6
    nco_offset: '0'
    rf_freq: RF_Frequency
    rf_oversampling: x2
    sample_rate: 10e6
  states: {}
- name: limesuiteng_sdrdevice_source_0
  id: limesuiteng_sdrdevice_source
  parameters:
    antenna: auto
    calibrate_dciq: Disabled
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: ''
    gain_generic: RX_Gain
    gfir_bandwidth: '0'
    link_format: i16
    lms7002m_gain_lna: '0'
    lms7002m_gain_pga: '0'
    lms7002m_gain_tia: '-3'
    lpf: 20e6
    nco_offset: '0'
    override_lms7002m_rx_gains: Disabled
    rf_freq: RF_Frequency
    rf_oversampling: x2
    sample_rate: 10e6
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"WaterFall"'
    ncols: fft_size
    nrows: '256'
    samp_rate: samp_rate/512
    type: float
    x_end_value: (samp_rate/2)/1e6
    x_label: '"Frequency, MHz"'
    x_start_value: '-(samp_rate/2)/1e6'
    y_label: '"Sweep"'
    zmax: '0'
    zmin: '-130'
  states: {}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    name: '"LimeSDR Shifted FFT"'
    vlen: fft_size
    x_axis_label: '"Frequency, MHz"'
    x_start: '-(samp_rate/2)/1e6'
    x_step: (samp_rate/1e6)/fft_size
    x_units: '"MHz"'
    y_axis_label: '"Amplitude, dBFS"'
    y_units: '"dBFS"'
  states: {}

connections:
- [analog_sig_source_x_0, '0', limesuiteng_sdrdevice_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_stream_to_vector_0_0_0_1, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_streams_to_vector_0, '0', qtgui_vector_sink_f_1, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0_0_0_1, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_streams_to_vector_0, '1']
- [blocks_vector_to_streams_0, '1', blocks_streams_to_vector_0, '0']
- [limesuiteng_sdrdevice_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
